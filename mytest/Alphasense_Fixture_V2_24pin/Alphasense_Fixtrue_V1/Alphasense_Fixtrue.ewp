# IAR project Alphasense_Fixtrue.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F6726A MSP430F6726A
  General.GStackSize2: 1536
  General.GHeapSize2: 256
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; ..\driverlib\MSP430F5xx_6xx; libs\BSP; libs\Abstraction; libs\Peripherals; libs\Sensors\AECL_4E_EC_GASES; libs\Peripharals; libs\Sensors\SHT3x
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6726a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c main.h
  group driverlib/Abstraction
    libs/Abstraction/: peripheral_abstraction.c peripheral_abstraction.h select_port.c select_port.h sensor_abstraction.c sensor_abstraction.h
  group driverlib/BSP
    libs/BSP/: crc2.c crc2.h include.h system.c system.h task.c task.h
  group driverlib/MSP430F5xx_6xx
    ../driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
  group driverlib/Peripharals
    libs/Peripharals/: hal_eusci_b_i2c.c hal_eusci_b_i2c.h hal_uart_txrx.c hal_uart_txrx.h ui_command.c ui_command.h
  group driverlib/Sensors/AECL_4E_EC_GASES
    libs/Sensors/AECL_4E_EC_GASES/: hal_aecl_4e_ec_gases.c hal_aecl_4e_ec_gases.h
  group driverlib/Sensors/SHT3x
    libs/Sensors/SHT3x/: sht3x.h sht3x_i2c_hal.h sht3x_native.c sht3x_typedefs.h

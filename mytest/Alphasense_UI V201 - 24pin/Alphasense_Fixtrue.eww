<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Alphasense_Fixtrue_V1\Alphasense_Fixtrue.ewp</path>
  </project>
  <batchBuild/>
</workspace>


